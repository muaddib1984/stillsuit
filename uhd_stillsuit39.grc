options:
  parameters:
    author: muaddib
    description: radio head for passing I/Q to other flowgraphs
    generate_options: no_gui
    id: uhd_oz39
    output_language: python
    run_options: run
  states: {}

blocks:
- name: control_ip
  id: parameter
  parameters:
    label: XMLRPC SERVER IP
    short_id: x
    type: str
    value: 127.0.0.1
  states: {}
- name: control_port
  id: parameter
  parameters:
    label: XMLRPC SERVER PORT
    short_id: X
    type: intx
    value: '8000'
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    label: RF FREQUENCY
    short_id: f
    type: eng_float
    value: 750e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF GAIN
    short_id: g
    type: eng_float
    value: '50.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMPLE RATE
    short_id: s
    type: eng_float
    value: 40e6
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rf_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_serv_ip
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: control_port
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://"+str(zmq_out_ip)+":"+str(zmq_out_port)'
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zmq_out_ip
  id: parameter
  parameters:
    label: ZMQ OUT IP ADDR
    short_id: o
    type: str
    value: 127.0.0.1
  states: {}
- name: zmq_out_port
  id: parameter
  parameters:
    label: ZMQ OUT IP PORT
    short_id: O
    value: '5000'
  states: {}

connections:
- [uhd_usrp_source_0, '0', zeromq_pub_sink_0_0, '0']

metadata:
  file_format: 1
