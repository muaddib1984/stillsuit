options:
  parameters:
    author: muaddib
    description: remote control/visual for stillsuit
    generate_options: qt_gui
    id: stillsuit_simple_controller_withfft
    output_language: python
  states: {}

blocks:
- name: rf_bw_gui
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: 200e3
    step: 1e3
    stop: 40e6
    value: samp_rate_gui*.8
  states: {}
- name: rf_freq_gui
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RF FREQ
    start: 64e6
    step: 100e3
    stop: 6e9
    value: 750e6
  states: {}
- name: rf_gain_gui
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: RF GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '80'
    value: '50'
  states: {}
- name: samp_rate_gui
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: 200e3
    step: 1e3
    stop: 40e6
    value: 2e6
  states: {}
- name: control_ip
  id: parameter
  parameters:
    label: XMLRPC SERVER IP
    short_id: x
    type: str
    value: 127.0.0.1
  states: {}
- name: control_port
  id: parameter
  parameters:
    label: XMLRPC SERVER PORT
    short_id: X
    type: intx
    value: '8002'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_gui
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rf_bw
  id: parameter
  parameters:
    label: RF BANDWITDH
    short_id: b
    type: eng_float
    value: 10e6
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    label: RF FREQUENCY
    short_id: f
    type: eng_float
    value: 750e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF GAIN
    short_id: g
    type: eng_float
    value: '20.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMPLE RATE
    short_id: s
    type: eng_float
    value: 2e6
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_gain
    port: '8000'
    variable: rf_gain_gui
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_freq
    port: '8000'
    variable: rf_freq_gui
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_bw
    port: '8000'
    variable: rf_bw_gui
  states: {}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_samp_rate
    port: '8000'
    variable: samp_rate_gui
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+str(zmq_in_ip)+":"+str(zmq_in_port)'
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zmq_in_ip
  id: parameter
  parameters:
    label: ZMQ IN IP ADDR
    short_id: z
    type: str
    value: 127.0.0.1
  states: {}
- name: zmq_in_port
  id: parameter
  parameters:
    label: ZMQ IN IP PORT
    short_id: Z
    type: str
    value: '5000'
  states: {}

connections:
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
